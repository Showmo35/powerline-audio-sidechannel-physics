options:
  parameters:
    author: xingya
    generate_options: qt_gui
    id: simple_rx
    output_language: python
    title: Simple Rx
  states: {}

blocks:
- name: duration
  id: variable
  parameters:
    value: int(samp_rate  * 20)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e5
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/anwesha/Documents/powerline_attack/data/sound_bar/chirp_img.bin
    type: float
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/anwesha/Documents/powerline_attack/data/sound_bar/alice_chap04_real.bin
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    name: Spectrum Analyzer - real
    showports: 'True'
    type: float
    wintype: window.WIN_BLACKMAN
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    name: Spectrum Analyzer - img
    plotwaterfall: 'False'
    showports: 'True'
    type: float
    wintype: window.WIN_BLACKMAN
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RXA
    bw0: samp_rate
    center_freq0: '0'
    clock_rate: '0.0'
    dev_args: '"addr=192.168.10.4"'
    gain0: '0'
    gain_type0: normalized
    rx_agc0: Disabled
    samp_rate: samp_rate
    sd_spec0: '"A:AB"'
    start_time: '-1'
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_sink_x_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_sink_x_1, '0']
- [blocks_complex_to_float_0, '1', blocks_file_sink_0_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_float_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
